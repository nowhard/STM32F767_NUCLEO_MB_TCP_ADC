# Keil uVision project MB_TCP_ADC.uvprojx, settings and files
target MB_TCP_ADC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: MB_TCP_ADC
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;                         ../Middlewares/Third_Party/LwIP/src/include;                         ../Middlewares/Third_Party/LwIP/system;                         ../Drivers/STM32F7xx_HAL_Driver/Inc;                         ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;                         ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                         ../Middlewares/Third_Party/LwIP/src/include/lwip;                         ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                         ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                         ../Middlewares/Third_Party/LwIP/src/include/netif;                         ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                         ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;                         ../Middlewares/Third_Party/LwIP/src/include/posix;                         ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                         ../Middlewares/Third_Party/LwIP/system/arch;                         ../Drivers/CMSIS/Include;                         ..\Middlewares\Third_Party\Modbus\include;                         ..\Middlewares\Third_Party\Modbus\functions;                         ..\Middlewares\Third_Party\Modbus\tcp;                         ..\Middlewares\Third_Party\Modbus\port;                         ..\Middlewares\Third_Party\Modbus
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c list.c queue.c timers.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c err.c api_msg.c tcpip.c sockets.c netifapi.c netdb.c netbuf.c pppapi.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip_frag.c icmp.c igmp.c ip4.c ip4_addr.c autoip.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c dhcp6.c icmp6.c ethip6.c inet6.c ip6_addr.c nd6.c ip6.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: magic.c multilink.c ecp.c eui64.c ipcp.c auth.c vj.c pppos.c eap.c demand.c fsm.c upap.c chap-md5.c pppcrypt.c mppe.c ccp.c utils.c chap-new.c pppoe.c chap_ms.c lcp.c ipv6cp.c ppp.c pppol2tp.c
    ../Middlewares/Third_Party/LwIP/src/core/: stats.c inet_chksum.c mem.c tcp.c lwip_timers.c tcp_out.c udp.c sys.c tcp_in.c memp.c dns.c pbuf.c def.c init.c netif.c raw.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c arc4.c sha1.c md5.c des.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: freertos.c ethernetif.c stm32f7xx_hal_msp.c stm32f7xx_it.c main.c lwip.c mbfunc.c mbinit.c udp_send.c data_converter.c spi_adc.c adc_dcmi.c tcp_send.c cfg_info.c
  group FreeModbus
    ../Middlewares/Third_Party/Modbus/: mb.c
    ../Middlewares/Third_Party/Modbus/tcp/: mbtcp.c
    ../Middlewares/Third_Party/Modbus/port/: portevent.c portother.c porttcp.c
    ../Middlewares/Third_Party/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
software components: CMSIS:CORE 4.1.0
